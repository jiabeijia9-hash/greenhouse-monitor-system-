# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: IAP15W4K58S4 STC
  cpu: IRAM(0-0xFF) IROM(0-0xE7FF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\
  group Source Group 1
    ./: main.c
